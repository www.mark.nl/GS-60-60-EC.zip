Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-01-25T13:02:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 25 13:02:59 2021 * Host: RCOJANU-RO-DE * Database: C:\Users\Rcojanu\AppData\Local\Temp\{B1E7AEB1-7EF9-4750-8E73-30D99F560C71}\ifc * Database version: 5507 * Database creation date: Mon Jan 25 13:02:58 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Jan 25 13:02:58 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 25 13:02:58 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcAirTerminal: GS+ 60 EC, VE_Air Heater_MEPcontent_Mark_GS+ 60-60 EC_INT-EN:GS+ 60 EC:1315296
In: V00
Type - Material: Color RGB 060-060-060, Color RGB 000-000-255, Color RGB 193-193-194
Type - Dimensions - Drain Diameter: 40 mm; Gas Diameter: 19 mm; Height: 812 mm; Length: 1120 mm; Use Nominal Diameter: yes; Width: 1001 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 340 W
Type - Identity Data - Article Type: GS+ 60 EC; Base Family Version: 12.21; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Gas-fired high performance air heater with axial modulating fan; EMCS Version: 4.0; ETIM Article Class: EC011395; Family Version: 11.19; Manufacturer: Mark; Manufacturer URL: http://www.markeire.com/air-heating/gas-fired/gs/; MEPcontent Class: AIR_HEATER; Model: GS+ 60 EC; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Revit Version: 2018; Type Name: GS+ 60 EC; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Air Flow Rate: 1.77778 m3/s; Heating Power: 608161; Nominal Flow Rate: 0 m3/s
Type - Other - Category: Mechanical Equipment; Body Width: 739 mm; Family Name: VE_Air Heater_MEPcontent_Mark_GS+ 60-60 EC_INT-EN; Length/2: 560 mm; Thread Offset: 50 mm; Thread Size: 10 mm
Type - Text - Article Description: Gas-fired high performance air heater with axial modulating fan; GTIN: 87193336250214; Manufacturer Art. No.: 5062502; Product Line: Mark
Type - Pset_AirTerminalTypeCommon - Reference: GS+ 60 EC
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 11.8351 m2; Flue Gas Diameter: 100 mm; Supply Air Diameter: 100 mm; Volume: 0.778366 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Gas Flow: 0 m3/s; System Classification: Supply Air,Undefined,Other,Power,Sanitary
Mechanical - Flow - Flue Gas Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Model Properties - Condensate Pump: no; Connection Diameter 100 mm: yes; Connection Diameter 130 mm: no; Pendant Length: 500 mm; Suspension Console: no
Other - Back Clearance: 227 mm; Condensate Pump Reference Line Offset: 906 mm; Drain Horizontal Offset: 167.5 mm; Drain Reference Line Angle: 90 deg; Drain Reference Line Front Offset: 449 mm; Drain Vertical Offset: 812 mm; Family: VE_Air Heater_MEPcontent_Mark_GS+ 60-60 EC_INT-EN: GS+ 60 EC; Family and Type: VE_Air Heater_MEPcontent_Mark_GS+ 60-60 EC_INT-EN: GS+ 60 EC; Horizontal Offset Safe: 0 mm; Pendants Visible: yes; Reference Line Length: 10 mm; Reference Line Offset: 449 mm; Safe Pendant Length: 500 mm; Type: VE_Air Heater_MEPcontent_Mark_GS+ 60-60 EC_INT-EN: GS+ 60 EC; Type Id: VE_Air Heater_MEPcontent_Mark_GS+ 60-60 EC_INT-EN: GS+ 60 EC; Vertical Offset: 500 mm
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Show Service Space: no
